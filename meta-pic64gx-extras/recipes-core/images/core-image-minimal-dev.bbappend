IMAGE_INSTALL:append:pic64gx-curiosity-kit = " \
    ffmpeg \
    vim \
    v4l-utils \
    gstreamer1.0 \
    gstreamer1.0-plugins-base \
    gstreamer1.0-plugins-good \
    gstreamer1.0-plugins-bad \
    gstreamer1.0-plugins-ugly \
    x264 \
    gst-examples \
    gstreamer1.0-plugins-base-videotestsrc \
    fswebcam  \
    pic64gx-soc-linux-examples \
    python3-asyncua \
    "

