FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/motd:"

FILESEXTRAPATHS:prepend:pic64gx-curiosity-kit := "${THISDIR}/${PN}/growfs:"
FILESEXTRAPATHS:prepend:pic64gx-curiosity-kit-amp := "${THISDIR}/${PN}/growfs:"

